Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2022-04-04T11:06:21
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20220111_1110(x64) - Exporter 19.2.50.16 - Alternate UI 19.2.50.16
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Mon Apr 04 11:06:21 2022* Host: NCL-ManOps17* Database: C:\Users\bateyjo\AppData\Local\Temp\{C3EF31BF-FC67-4C2B-A784-C2C1BEDBDFD9}\ifc* Database version: 5507* Database creation date: Mon Apr 04 11:06:20 2022* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Mon Apr 04 11:06:20 2022* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Mon Apr 04 11:06:20 2022* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 51, 30, 23, 112487; RefLongitude: 0, -7, -37, -956022; RefElevation: 0 mm

# IfcBuildingStorey, Level 0
LongName: Level 0; Elevation: 0 mm

# IfcFurnishingElement: FinionMirrorG60010, NBS_VilleroyAndBochAG_BthrmMrrs_FinionMirrorG60010:FinionMirrorG60010:420754
In: Level 0
Type - ElementType: FinionMirrorG60010; Classification: Pr_25_71_53_06 (Uniclass2015); Material: NBS_VilleroyAndBoch_Mirror, NBS_VilleroyAndBoch_FrostedGlass
Type - BOS_General - Author: NBS; BIMObjectName: NBS_VilleroyAndBochAG_BathroomMirrors_FinionMirrorG60010; ManufacturerName: Villeroy & Boch AG; ManufacturerURL: https://pro.villeroy-boch.com; NBSCertification: www.nationalbimlibrary.com/cert/vwvlxr5y; ProductInformation: n/a; Uniclass2015Title: Bathroom mirrors; Uniclass2015Code: Pr_25_71_53_06; Uniclass2015Version: Products v1.22; Version: 2
Type - NBS_Data - Colour: 2700 K (neutral white) to 6480 K (daylight white); ContainsRedListMaterials: n/a; CountryOfMaterialOrigin: n/a; CountryOfProductManufacture: n/a; Dimensions: 1000 x 750 x 45 mm; EmbodiedCarbon: n/a; Form: Wall mounted; IngressProtection: 44; IntegralAccessories: None, G999 02 00 remote; LEDLighting: 1 x LED (23.9 W), 1 x LED (47.7 W); Manufacturer: Villeroy and Boch; MaterialsFrame: n/a; MaterialsGlazing: Glass; PowerSupply: Mains-operated; Recyclability: n/a; RecycledContent: n/a; Weight: 13 kg
Type - IFC - IfcExportAs: IfcFurnitureType; IfcExportType: BATHMIRROR
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_25_71_53_06:Bathroom mirrors; CodePerformance: n/a; Color: n/a; Constituents: n/a; Description: n/a; DurationUnit: year; ExpectedLife: n/a; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: Villeroy and Boch; Material: n/a; ModelNumber: n/a; ModelReference: FinionMirrorG60010; Name: BathroomMirrors_FinionMirrorG60010_VilleroyAndBochAG; NominalHeight: 750 mm; NominalLength: 0 mm; NominalWidth: 1000 mm; ReplacementCost: n/a; Shape: n/a; Size: n/a; SustainabilityPerformance: n/a; WarrantyDescription: n/a; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
